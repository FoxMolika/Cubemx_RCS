# Keil uVision project keil_compiler_options.uvprojx, settings and files
target CompilerOptionsRegression ()
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: KEEP_TARGET
  c include: ../Core/Inc;../Modules
  group Chassis
    ../Modules/: rcs_chassis.c rcs_control.c rcs_hal.c
